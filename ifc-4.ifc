Properties of the parts of a building model (IFC4)

# File
Description: Funk-Temperaturaktor Heizen/Kühlen zur Montage im Heizkreisverteiler, 4-Kanal, IP20, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BA121500, Funk-Temperaturaktor Heizen/Kühlen zur Montage im Heizkreisverteiler, 4-Kanal, IP20
In: Raum
Description: Funkaktoren (Funk-Temperaturregler) für Heizen/Kühlen, die in Verbindung mit alre-Funk-Raumtemperatursensoren eine Einzelraum-Temperaturregelung verwirklichen. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen.4-Kanal Funk-Temperaturaktor zur Montage im Heizkreisverteiler. max. 3 Stellantriebe pro Kanal direkt anschließbar / max. 11 Stellantriebe gesamt, inklusive Pumpenmodul, eine Zeitzone je Kanal möglich, Master-Slave-Betrieb, Mittelwertbildung mit bis zu 8 Messstellen. Das Oberteil kann zum Anlernen der Funksensoren in den einzelnen Räumen abgenommen werden. Voraussetzung dafür ist die Verwendung einer optionalen, handelsüblichen 9 V Batterie. Durch die Kanalauswahl- und eine Anlerntaste kann das Anlernen der Sensoren sehr einfach durchgeführt werden.; Classification: EC010057 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BA121500; ModelLabel: KTFRL-214.140; GlobalTradeItemNumber: 4050528076823; ProductURL: https://alre.de/produkt_BA121500
Pset_Specification - NominalLength: 0.197 m; NominalWidth: 0.1 m; NominalDepth: 0.0615 m; NetWeight: 0.552
Pset_ALRE_ETIM_Properties - Breite: 197; Höhe: 100; Tiefe: 61.5; Versorgungsspannung: 230; Ausgangsspannung: 230; Mit Zeitschaltuhr: no; Kontaktausführung: Schließer (NO); Anschluss für externe Antenne: yes; Schutzart (IP): IP20; Vernetzbar über Funk (standardmäßig): yes; Max. Spannung der Kontakte: 230; Mit zusätzlichem Kontakt: yes; Empfangsfrequenz: 868.3; Anzahl der Kanäle/Zone: 4; Max. Kontaktbelastung: 3; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010057; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BA121500.pdf
